# Keil uVision project STM32F4XX_BASE.uvprojx, settings and files
target STM32F4_BASE (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4XX_BASE +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWlib\inc;..\BSP\sys;..\APPS\LED;..\BSP\iic;..\BSP\delay;..\APPS\W5500;..\BSP\spi;..\BSP\timer;..\BSP\usart;..\BSP\boot
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APPS
    ../APPS/LED/: led.c
  group BSP
    ../BSP/delay/: delay.c
    ../BSP/sys/: sys.c
    ../BSP/spi/: spi1.c my_spi.c
    ../BSP/iic/: myiic.c
    ../BSP/timer/: timer.c
    ../BSP/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40xx.s
  group FWlib
    ../FWlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_flash.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group W5500
    ../APPS/W5500/: at24cxx.c loopback.c md5.c socket.c util.c w5500.c w5500_conf.c
